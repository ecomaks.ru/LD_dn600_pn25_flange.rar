# KOMPAS-3D part (DN600 НП ФИ PN25.m3d)

Model tree:
1. Операция без истории:1

Texts:
  DN600 НП ФИ PN25